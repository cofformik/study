P8255A EQU 0640H
P8255B EQU 0642H
P8255C EQU 0646H
P8255MODE EQU 0646H
CODE SEGMENT
		ASSUME CS:CODE
START:
		MOV DX,P8255MODE
		MOV AL,10010000B
		OUT DX,AL				;送方式控制字
		
NEXT:
		MOV DX,P8255A
		IN  AL,DX				;读a口
		AND AL,01H
		JZ  A1					;K0为低电平
		MOV AL,0F0H				;数据灯高四位亮
		JMP A2
A1:		MOV AL,0FH				;数据灯低四位亮
		
A2:		MOV DX,P8255B
		OUT DX,AL				;送b口
		JMP NEXT


		
OVER:	MOV AH,4CH
		INT 21H
CODE ENDS
		END START